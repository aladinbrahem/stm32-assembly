# Keil uVision project stm32f7.uvprojx, settings and files
target stm32f7_assembly (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: stm32f7 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\stm32f746
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --entry Reset_Handler   --diag_suppress=L6314
  group STARTUP
    ./: startup_stm32f746.s stm32f746_hal.s
  group BSP
    ./: bsp_led.s bsp_timer.s
  group USER
    ./: main.s
  group CMSIS
    ./: system_stm32f746.s
